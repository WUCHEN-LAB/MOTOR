# Keil uVision project PID.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: PID +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\head
  group Source Group 1
    ./: STARTUP.A51
    ../code/: PID.c
    ../head/: PID.h
